<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>98</value></param>
<param><key>grid_pos</key><value>0,0,2,12</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>max</key><value>108</value></param>
<param><key>min</key><value>88</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>False</value></param>
<param><key>bw</key><value>5000</value></param>
<param><key>biasT</key><value>False</value></param>
<param><key>bcast_notch</key><value>False</value></param>
<param><key>dab_notch</key><value>False</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>0</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>0</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>freq*1e6</value></param>
<param><key>sample_rate</key><value>2e6</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>2e6</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
